# IAR project tt.ewp, settings and files
configuration SG3 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: SG3
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SGOLD
  XLINK.XclFile: elf\elf.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: main.c
  group elf
    elf/: elf.c unicode.c
  group images
    ./: star.c thing.c
