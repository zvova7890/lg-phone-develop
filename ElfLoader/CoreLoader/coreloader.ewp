# IAR project coreloader.ewp, settings and files
configuration KP501_V10H_00 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: VKP\KP501_V10H_00\XCL.xcl
  group (top)
    ./: elf.c fwlib.c init.c init_hook.asm
