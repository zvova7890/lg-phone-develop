# IAR project core.ewp, settings and files
configuration KP501_v10H_00 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.PreInclude: unidata\kp501_v10H_00.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: core.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: amem.c core.c ejapi.c ejapi_hook.asm exekiller.c imb.asm init.c pxeapi.c remap.c swihook.c swihook_body.asm
  group loader3
    loader3/: env.c env.h initializer.c loadelf.c loader.c loader.h loadlib.c log.c mode.h
