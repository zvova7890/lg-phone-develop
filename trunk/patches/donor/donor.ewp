# IAR project donor.ewp, settings and files
configuration SG3 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: SG3
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SGOLD
  XLINK.XclFile: bin.xcl
  group (top)
    ./: boot.asm main.c
