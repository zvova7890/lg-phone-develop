# IAR project core.ewp, settings and files
configuration KP501_v10H_00 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: SG3
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SGOLD
  XLINK.XclFile: core.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: amem.c core.c ejapi.c ejapi_hook.asm elf.c IMB.asm init.c swihook.c swihook_body.asm
    loader3/: elf.h
  group loader3
    loader3/: env.c env.h initializer.c loadelf.c loader.c loader.h loadlib.c log.c mode.h
